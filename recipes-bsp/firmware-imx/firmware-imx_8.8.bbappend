SRC_URI += "file://epdc_PENG060D.fw;subdir=firmware-imx-8.8/firmware/epdc/"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


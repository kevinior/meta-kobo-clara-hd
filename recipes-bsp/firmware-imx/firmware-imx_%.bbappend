SRC_URI += "file://epdc_PENG060D.fw;subdir=firmware-imx-${PV}/firmware/epdc/"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

